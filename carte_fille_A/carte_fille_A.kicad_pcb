# Repository rahim974/3Dscan2A (continued)

## KiCad design carte_fille_A/carte_fille_A.kicad_pcb (continued)

Board: 2 copper layers, 75 parts (4 on the bottom side), 34 nets, no tracks yet.

Other parts of the board:
C13: 100nF; C_0402_1005Metric

Their connections:
+3V3: C13.1; also elsewhere on the board
GND: C13.2; also elsewhere on the board
